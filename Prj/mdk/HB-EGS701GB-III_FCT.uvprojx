# Keil uVision project HB-EGS701GB-III_FCT.uvprojx, settings and files
target GB-III_FCT (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F105ZE GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HB-EGS701GB-III_FCT
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Bin/HB-EGS701GB-III_FCT.bin ./Objects/HB-EGS701GB-III_FCT.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\base_kernel\Libraries\CMSIS\CM3\CoreSupport;..\..\base_kernel\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\base_kernel\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\base_kernel\rt-thread\include;..\..\base_kernel\rt-thread\src;..\..\base_kernel\rt-thread\libcpu\arm\cortex-m3;..\..\base_kernel\rt-thread\libcpu\arm\common;..\..\base_kernel\rt-thread\drivers;..\..\User\App\inc;..\..\base_kernel\rt-thread\components\drivers\include;..\..\User\Api\inc;..\..\User\driver\inc;..\..\User\fct\inc;..\..\base_kernel\rt-thread\components\drivers\include\drivers;..\..\base_kernel\rt-thread\components\dfs\include;..\..\base_kernel\rt-thread\components\dfs\filesystems\elmfat;..\..\base_kernel\rt-thread\components\dfs\filesystems\devfs;..\..\base_kernel\rt-thread\components\drivers\spi;..\..\base_kernel\rt-thread\components\drivers\spi\sfud\inc;..\..\base_kernel\rt-thread\components\libc\compilers\armlibc;..\..\base_kernel\rt-thread\components\finsh
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Cmsis
    ../../base_kernel/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../base_kernel/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group STM32_StdPeriph
    ../../base_kernel/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
  group Api
    ../../User/Api/src/: ApiTimer.c Public.c
  group App
    ../../User/App/src/: queue.c SystemInit.c rtc.c Adc.c WDogManage.c taskschedule.c adc_tran_voltag.c user_finsh_cmd.c
  group Fct
    ../../User/fct/src/: CommParam.c fct_driver.c fct_app.c CommTest2.c CommTest4.c CommTest5.c
  group Drivers
    ../../base_kernel/rt-thread/drivers/: board.c
    ../../User/driver/src/: Usart_drive.c comm.c usart.c gpio.c mmc_sd.c spi.c spi_flash.c E2prom_25LC320A.c fm25c160.c EepromPram.c
  group Kernel
    ../../base_kernel/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Cortex_m3
    ../../base_kernel/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../base_kernel/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../base_kernel/rt-thread/components/drivers/serial/: serial.c
    ../../base_kernel/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../base_kernel/rt-thread/components/drivers/misc/: pin.c
    ../../User/driver/src/: rt_template.c spi_master.c
    ../../base_kernel/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c spi_msd.c
    ../../base_kernel/rt-thread/components/drivers/spi/sfud/src/: sfud.c
  group FileSystem
    ../../base_kernel/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../base_kernel/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../base_kernel/rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c cc936.c
    ../../base_kernel/rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../base_kernel/rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c msh.c msh_cmd.c msh_file.c
  group Libc
    ../../base_kernel/rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group Fat_fs
    ../../base_kernel/Libraries/FAT_FS/src/: ff.c fattime.c
    ../../base_kernel/Libraries/FAT_FS/src/option/: ccsbcs.c
  group USB_Driver
    ../../base_kernel/Libraries/USB_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_Lib
    ../../base_kernel/Libraries/USB_Lib/Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../base_kernel/Libraries/USB_Lib/Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_App
    ../../base_kernel/Libraries/USB_App/src/: usb_app.c usb_bsp.c usbh_usr.c
